# Keil uVision project smartcar.uvproj, settings and files
target main (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: smartcar +hex
  c flags: Optimize=8 SizeSpeed=1
  group include
    ./: config.h protocol.h
  group source
    ./: main.c
